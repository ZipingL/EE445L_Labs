# Keil uVision project Lab3.uvproj, settings and files
target Lab3 (ARM-ADS)
  device: TM4C1232H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab3
  c flags: Optim=1 uC99=1
  c include: ..\..\ValvanoWareTM4C123
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.c ST7735.c PLL.c driver-lcd.c driver-sound.c driver-switch.c driver-systick.c
